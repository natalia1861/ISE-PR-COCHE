# Keil uVision project Coche.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Coche
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000
  c include: ..\Common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c
  group app_tasks
    ./: nRF24L01_RX.c distance_control.c app_main.c consumo_control.c
    ../Common/: leds_control.c
  group Driver
    ../Common/: tm_stm32_exti.c tm_stm32_gpio.c tm_stm32_nrf24l01.c tm_stm32_spi.c adc.c
    ./: i2c.c VL53L0X.c servomotor.c modo_sleep.c
  group GPIO
    ./: gpio.c
    ../Common/: nak_led.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Board Support:LED 1.0.0, CMSIS Driver:Ethernet MAC 2.10, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, CMSIS Driver:I2C 2.12, CMSIS Driver:SPI 2.18, CMSIS Driver:USART 2.16, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:ADC 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:I2C 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:RTC 1.8.1, Device:STM32Cube HAL:SPI 1.8.1, Device:STM32Cube HAL:SRAM 1.8.1, Device:STM32Cube HAL:TIM 1.8.1, Device:STM32Cube HAL:USART 1.8.1, Device:Startup 2.6.3
